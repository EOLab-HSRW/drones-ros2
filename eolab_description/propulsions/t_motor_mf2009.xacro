Commit message: fix invalid URDF

File: eolab_description/propulsions/t_motor_mf2009.xacro (robot description, xacro)
@@ -20,5 +20,4 @@
         </geometry>
       </collision>
-      <mass value="${prop_weight}"/>
       <!-- real value heavy-->
       <!-- <mass value="5.5"/> -->
